# Keil uVision project Project.uvprojx, settings and files
target ANO_FLY_F4 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F4XX, USE_STDPERIPH_DRIVER,VERSIONSBY=2
  c misc: --c99
  c include: ..\User;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\User\Dirver;..\GLIB\SYSTEM;..\User\TASK;..\GLIB\HARDWARE;..\User\CONFIG;..\User\APP;..\GLIB\PERIPHERAL\PX4FLOW;..\GLIB\HARDWARE;..\User;..\GLIB\PERIPHERAL\OLED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c Imu.c Imu.h Control.c Control.h Rc.c Rc.h
    ../User/Dirver/: Flash_Eeprom.c
    ../User/APP/: data_transfer.c Balance.cpp motor.c
  group Startup
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_sdio.c stm32f4xx_i2c.c stm32f4xx_flash.c stm32f4xx_spi.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Readme
    ../User/: readme.txt
  group Dirver
    ../User/Dirver/: MPU6050.c MPU6050.h
    ../GLIB/PERIPHERAL/PX4FLOW/: PX4FLOW.c
    ../GLIB/PERIPHERAL/OLED/: Oled.c
  group IIC_LIB
    ../User/Dirver/: ANO_Tech_STM32_I2C.h ANO_Tech_STM32_I2C.lib
  group TASK
    ../User/TASK/: task_6050.h loop_fast.h task_pwm_ex.h task_bmp085.cpp task_ultrasonic.h task_PX4FLOW.h task_cap_rc.h task_Oled.h
  group SYSTEM
    ../GLIB/SYSTEM/: sys_os.c sys.c sys_usart.c usr_usart.c minos_delay.c usart.c
  group HARDWARE
    ../GLIB/HARDWARE/: pwm.c G32_Timer.c G32_Timer_Cap.c G32_I2c.c
